CMDLINE_SERIAL:append = " cma=128M"