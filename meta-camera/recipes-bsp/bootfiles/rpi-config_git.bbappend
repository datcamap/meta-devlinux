RPI_EXTRA_CONFIG:append = "\n\
    dtoverlay=imx708\n\
"