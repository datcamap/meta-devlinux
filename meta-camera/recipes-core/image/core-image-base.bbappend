# IMAGE_INSTALL:append = " imx708-overlay"
IMAGE_INSTALL:append = " v4l-utils"
IMAGE_INSTALL:append = " libcamera"