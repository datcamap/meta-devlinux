IMAGE_INSTALL:append = " v4l-utils"
IMAGE_INSTALL:append = " libcamera"
IMAGE_INSTALL:append = " libcamera-apps"