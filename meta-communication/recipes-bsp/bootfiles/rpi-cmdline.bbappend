SERIAL_CONSOLES = "115200;ttyAMA0"
CMDLINE_SERIAL:append = " console=serial0,115200 vt.global_cursor_default=0"