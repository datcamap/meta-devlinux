RPI_EXTRA_CONFIG:append = "\n\
enable_uart=1\n\
dtoverlay=disable-bt\n\
dtoverlay=imx708\n"
