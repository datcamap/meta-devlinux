IMAGE_INSTALL:append = " \
    kernel-module-spi-bcm2835 \
    kernel-module-spi-bcm2835aux \
    kernel-module-ili9225 \
"