RDEPENDS:${PN}:append = "\
    kernel-module-spi-bcm2835 \
    kernel-module-spi-bcm2835aux \
    imagemagick \
    xz \
    rpidistro-ffmpeg \
    lsof \
    file \
"