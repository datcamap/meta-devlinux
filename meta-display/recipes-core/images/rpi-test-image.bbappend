IMAGE_INSTALL:append = " my-overlay"
